SRC_URI += "file://bsp.cfg \
            file://user_2020-01-28-22-10-00.cfg \
            file://user_2020-01-29-21-14-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
