SRC_URI += "file://bsp.cfg \
            file://user_2020-01-28-21-20-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
