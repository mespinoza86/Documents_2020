SRC_URI += "file://bsp.cfg \
            file://user_2020-01-26-23-18-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
