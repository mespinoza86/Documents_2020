## 2020/build_root_glib/buildroot-2019.11.1/package/neuronalinfoli/Config.in
```kconfig
config BR2_PACKAGE_NEURONALINFOLI
	bool "neuronalinfoli"
	help
		hello world mpi package
```
